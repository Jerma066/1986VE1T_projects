# Keil uVision project New_Uart.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MDR1986BE1T Milandr
  pack: Keil.MDR1986BExx.1.4
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: New_Uart
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group Source Group 1
    ./: main.c uart.c clk.c rtos.c LCD_b.c LCD.c make_command.c LCDGraphic.c
software components: CMSIS:CORE 5.1.2, CMSIS:RTOS2:Keil RTX5 5.4.0, Device:Startup_MDR1986BE1T 1.3.1, Drivers:PORT 1.3.1, Drivers:RST_CLK 1.3.1, Drivers:UART 1.3.1
